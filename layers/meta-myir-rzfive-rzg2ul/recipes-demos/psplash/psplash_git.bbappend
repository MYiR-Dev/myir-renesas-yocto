# MYIR - 2023   Mark .
FILESEXTRAPATHS_prepend_poky := "${THISDIR}/files:"
